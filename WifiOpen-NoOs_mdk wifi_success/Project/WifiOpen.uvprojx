# Keil uVision project WifiOpen.uvprojx, settings and files
target WifiOpen (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: WifiOpen +hex
  c flags: Optim=1 wLevel=1
  c define: STM32F10X_HD
  c include: ..\Bsp;..\Drivers\FWLib\Inc;..\Drivers\Wifi\IF;..\Drivers\Wifi\IO;..\Drivers\Wifi\WLAN;..\Drivers\Wifi\Inc;..\Drivers\Wifi\API;..\Include;..\Init;..\Net;..\System;..\Drivers\GSPI;..\Drivers\Buzzer;..\Drivers\Relay;..\Drivers\IntFlash;..\Drivers\LED;..\Drivers\Console;..\Drivers\Uart;..\uCOS\core;..\uCOS\port;..\Net\uip_1_0\uip;..\Net\uip_1_0\apps\webserver;..\Net\uip_1_0\lib;..\Net\uip_1_0\unix;..\Net\uip_1_0\apps\dhcps;..\Net\uip_1_0\apps\lingtone_apps;..\uIP-APP
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group BSP
    ../Bsp/: UartTrace.c board_init.c core_cm3.c hw_config.c startup_stm32f10x_hd.s stm32f10x_it.c system_stm32f10x.c
  group STM32FWLib
    ../Net/uIP_1_0/uip/: psock.c
    ../Drivers/FWLib/src/: stm32f10x_usart.c misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c
  group Drivers
    ../Drivers/Buzzer/: Buzzer.c
    ../Drivers/Console/: Console.c
    ../Drivers/GSPI/: GSPI.c
    ../Drivers/IntFlash/: Flash.c
    ../Drivers/LED/: LED.c
    ../Drivers/Relay/: Relay.c
    ../Drivers/Uart/: Uart.c
  group WifiStack
    ../Drivers/Wifi/Api/: WifiApiExport.c WifiApiPrivate.c WiFiCommand.c
    ../Drivers/Wifi/IF/: Wifi_If.c
    ../Drivers/Wifi/IO/: Wifi_Hw.c
    ../Drivers/Wifi/WLAN/: WlanAdapter.c WlanCmd.c WlanInit.c WlanMisc.c WlanPkt.c
  group uIP
    ../Net/uIP_1_0/uip/: timer.c uip.c uip_arp.c uip-fw.c uiplib.c uip-neighbor.c uip-split.c
    ../Net/uIP_1_0/unix/: clock-arch.c tapdev.c uIP_App.c
  group Include
    ../Include/: app_cfg.h BaseDefs.h BaseTypes.h Project.h WifiCfg.h WifiUser.h
  group Init
    ../Init/: Main.c
  group System
    ../System/: SysClock.c
  group wifi
    ../uIP-APP/: stm32f10x_tim.c timerx.c tcp_client_demo.c tcp_demo.c tcp_server_demo.c AD.c
software components: CMSIS:CORE 4.3.0
